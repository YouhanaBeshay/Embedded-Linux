## Embedded_linux_task10/iti-qt-gpio/Config.in
```kconfig
config BR2_PACKAGE_ITI_QT_GPIO
	bool "iti-qt-gpio"
	depends on BR2_PACKAGE_QT6BASE
    default y
	help
	  A Qt6-based GPIO application.
```
